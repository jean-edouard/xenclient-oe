FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://fix-32-bit-overflow.patch \
"
