PR .= ".1"

RDEPENDS_packagegroup-base-keyboard = "\
    kbd \
"
