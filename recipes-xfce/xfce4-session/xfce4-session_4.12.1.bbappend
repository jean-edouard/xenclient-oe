RDEPENDS_${PN}_remove += "upower"
